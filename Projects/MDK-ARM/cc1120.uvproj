# Keil uVision project cc1120.uvproj, settings and files
target cc1120 Configuration (ARM-ADS)
  device: STM32F303CB STMicroelectronics
  cpu: IRAM(0x20000000-0x200077FF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
				FPU2
  output: cc1120 Configuration +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\Drivers\CMSIS\Include; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\Inc; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ; ..\..\Drivers\CMSIS\Include
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c usb_device.c usbd_conf.c usbd_desc.c
  group Application/cc1125
    ../../Src/: drv_cc1125.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303xc.s
